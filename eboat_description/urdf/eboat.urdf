Commit message: Feat: RViz

File: eboat_description/urdf/eboat.urdf (robot description, URDF)
Before this commit: robot eboat4, 23 links, 22 joints
Links:
- link lidar_link: geometry collision cylinder length=0.2 radius=0.05; visual cylinder length=0.2 radius=0.05
